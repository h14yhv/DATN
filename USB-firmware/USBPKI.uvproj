# Keil uVision project USBPKI.uvproj, settings and files
target AT91SAM7S-EK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT91SAM7S256 Atmel
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(20000000) CPUTYPE(ARM7TDMI)
  output: USBPKI +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  group Startup Code
    ./: SAM7.s
  group Source Code
    ./: USBPKI.c USBPKI.h Global.h crc.c crc.h demo.h Token.c
  group Documentation
    ./: Abstract.txt
  group SPI
    ./: spi.c
  group UART
    ./: Time.c ExtInt.c Retarget.c Serial.c IRQ0.s
  group USB
    ./: usbuser.c usbdesc.c usbcore.c usbhw.c usbcfg.h
